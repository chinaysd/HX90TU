# Keil uVision project HX90TU.uvproj, settings and files
target HX90TU (MCS-51)
  device: SC92F8270 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFF)  XRAM(0-0x7F) CLOCK(24000000)
  output: HX90TU +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user;..\touch_lib
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC92F827X_C.H
  group bsp
    ../bsp/: bsp_line.c
  group touch_lib
    ../touch_lib/: S_TouchKeyCFG.C SC92F8X7X_HighReliability_Lib_T1_V0.0.1.LIB
